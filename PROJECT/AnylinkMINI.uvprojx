# Keil uVision project AnylinkMINI.uvprojx, settings and files
target AnylinkMINI (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AnylinkMINI +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32_DRIVER\CORE;..\STM32_DRIVER\ROOT;..\STM32_DRIVER\STM32F10x_StdPeriph_Driver\inc;..\USER\DRIVER;..\USER\INCLUDE;..\USER\LORA;..\USER\DRIVER\usart;..\USER\DRIVER\Iwdg;..\USER\DRIVER\Sx1278Init
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group MAIN
    ../USER/MAIN/: MAIN.C
  group LORA
    ../USER/LORA/: radio.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-Hal.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group SYSTEM
    ../USER/MAIN/: Flash.c Sys1msInit.C Sys.c Led.c
    ../USER/DRIVER/Iwdg/: Iwdg.c
    ../USER/DRIVER/Sx1278Init/: Sx1278Init.c
    ../USER/DRIVER/Usart/: usart.c
  group CORE
    ../STM32_DRIVER/CORE/: core_cm3.c startup_stm32f10x_hd.s
  group ROOT
    ../STM32_DRIVER/ROOT/: stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../STM32_DRIVER/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
